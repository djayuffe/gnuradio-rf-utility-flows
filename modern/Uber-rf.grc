<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>Uberrf</value></param>
<param><key>title</key><value>ask_rx_fcd</value></param>
<param><key>author</key><value>Ulf Bertilsson</value></param>
<param><key>description</key><value>Modern GNU Radio Companion flowgraph validated for this repository.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>output_language</key><value>python</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>xlate_filter_taps</value></param>
<param><key>value</key><value>firdes.low_pass(1000, samp_rate, 48000, 10000, firdes.WIN_HAMMING, 6.76)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>LO</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_fine</value></param>
<param><key>label</key><value>Fine tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-1000</value></param>
<param><key>max</key><value>1000</value></param>
<param><key>num_steps</key><value>400</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,0,1,2</value></param>
<param><key>start</key><value>-1000</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>(1000 - -1000) / 400</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>lo_freq</value></param>
<param><key>label</key><value>LO</value></param>
<param><key>value</key><value>LO</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,2,1,1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>label</key><value>Receive</value></param>
<param><key>value</key><value>LO+freq+(offset_coarse+offset_fine)</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>5,3,1,1</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency</value></param>
<param><key>value</key><value>433.967e6</value></param>
<param><key>min</key><value>100e6</value></param>
<param><key>max</key><value>1e9</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>8,0,1,6</value></param>
<param><key>start</key><value>100e6</value></param>
<param><key>stop</key><value>1e9</value></param>
<param><key>step</key><value>(1e9 - 100e6) / 960</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>width</value></param>
<param><key>label</key><value>Filter</value></param>
<param><key>value</key><value>30000</value></param>
<param><key>min</key><value>2000</value></param>
<param><key>max</key><value>400000</value></param>
<param><key>num_steps</key><value>760</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,0,1,1</value></param>
<param><key>start</key><value>2000</value></param>
<param><key>stop</key><value>400000</value></param>
<param><key>step</key><value>(400000 - 2000) / 760</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>offset_coarse</value></param>
<param><key>label</key><value>Coarse tune</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>-40000</value></param>
<param><key>max</key><value>40000</value></param>
<param><key>num_steps</key><value>960</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>6,2,1,2</value></param>
<param><key>start</key><value>-40000</value></param>
<param><key>stop</key><value>40000</value></param>
<param><key>step</key><value>(40000 - -40000) / 960</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>display_selector</value></param>
<param><key>label</key><value>Spectrum</value></param>
<param><key>value</key><value>1</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>labels</key><value>['Baseband','Frequency']</value></param>
<param><key>type</key><value>raw</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>grid_pos</key><value>5,0,1,1</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>options</key><value>[0, 1]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>af_gain</value></param>
<param><key>label</key><value>VOL</value></param>
<param><key>value</key><value>1</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>5</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,3,1,1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>5</value></param>
<param><key>step</key><value>(5 - 0) / 50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain</value></param>
<param><key>label</key><value>RF</value></param>
<param><key>value</key><value>10</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>50</value></param>
<param><key>num_steps</key><value>50</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,1,1,1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>50</value></param>
<param><key>step</key><value>(50 - 0) / 50</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>trans</value></param>
<param><key>label</key><value>Trans</value></param>
<param><key>value</key><value>1500</value></param>
<param><key>min</key><value>500</value></param>
<param><key>max</key><value>5000</value></param>
<param><key>num_steps</key><value>900</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>grid_pos</key><value>7,2,1,1</value></param>
<param><key>start</key><value>500</value></param>
<param><key>stop</key><value>5000</value></param>
<param><key>step</key><value>(5000 - 500) / 900</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>rf_gain2</value></param>
<param><key>label</key><value>rf_gain2</value></param>
<param><key>value</key><value>0</value></param>
<param><key>min</key><value>0</value></param>
<param><key>max</key><value>100</value></param>
<param><key>num_steps</key><value>100</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>(100 - 0) / 100</value></param>
</block>
<block>
<key>low_pass_filter</key>
<param><key>id</key><value>low_pass_filter</value></param>
<param><key>type</key><value>fir_filter_ccf</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>gain</key><value>1</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>cutoff_freq</key><value>width/2</value></param>
<param><key>width</key><value>trans</value></param>
<param><key>win</key><value>firdes.WIN_HAMMING</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>fftsink</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>baseband_freq</key><value>rx_freq*display_selector</value></param>
<param><key>y_per_div</key><value>10</value></param>
<param><key>y_divs</key><value>10</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>ref_scale</key><value>100</value></param>
<param><key>fft_size</key><value>512</value></param>
<param><key>fft_rate</key><value>60</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>average</key><value>True</value></param>
<param><key>avg_alpha</key><value>0.5</value></param>
<param><key>win</key><value>None</value></param>
<param><key>win_size</key><value>800,300</value></param>
<param><key>grid_pos</key><value>0,0,5,4</value></param>
<param><key>freqvar</key><value>None</value></param>
<param><key>name</key><value>'fftsink'</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>bw</key><value>samp_rate</value></param>
</block>
<block>
<key>analog_am_demod_cf</key>
<param><key>id</key><value>blks2_am_demod_cf_0</value></param>
<param><key>chan_rate</key><value>48000</value></param>
<param><key>audio_decim</key><value>2</value></param>
<param><key>audio_pass</key><value>500</value></param>
<param><key>audio_stop</key><value>8000</value></param>
</block>
<block>
<key>blocks_file_sink</key>
<param><key>id</key><value>gr_file_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>file</key><value>captures/demodulated.float32</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>const</key><value>af_gain</value></param>
</block>
<block>
<key>audio_sink</key>
<param><key>id</key><value>audio_sink_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>samp_rate</key><value>44100</value></param>
<param><key>ok_to_block</key><value>False</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>wxgui_scopesink2_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>title</key><value>Scope Plot</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>v_scale</key><value>1</value></param>
<param><key>v_offset</key><value>0</value></param>
<param><key>t_scale</key><value>.001</value></param>
<param><key>ac_couple</key><value>False</value></param>
<param><key>xy_mode</key><value>False</value></param>
<param><key>num_inputs</key><value>1</value></param>
<param><key>trig_mode</key><value>wxgui.TRIG_MODE_AUTO</value></param>
<param><key>y_axis_label</key><value>Counts</value></param>
<param><key>name</key><value>'Scope Plot'</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>size</key><value>1024</value></param>
</block>
<block>
<key>freq_xlating_fir_filter_xxx</key>
<param><key>id</key><value>xlating_fir_filter</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>xlate_filter_taps</value></param>
<param><key>center_freq</key><value>-(offset_coarse+offset_fine)</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
</block>
<block>
<key>osmosdr_source</key>
<param><key>id</key><value>osmosdr_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>args</key><value></value></param>
<param><key>sample_rate</key><value>samp_rate</value></param>
<param><key>freq0</key><value>freq</value></param>
<param><key>gain_mode0</key><value>False</value></param>
<param><key>gain0</key><value>rf_gain</value></param>
<param><key>if_gain0</key><value>20</value></param>
<param><key>bb_gain0</key><value>rf_gain2</value></param>
</block>
<connection><source_block_id>blks2_am_demod_cf_0</source_block_id><sink_block_id>gr_multiply_const_vxx_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>fftsink</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>gr_file_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>wxgui_scopesink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>low_pass_filter</source_block_id><sink_block_id>blks2_am_demod_cf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>osmosdr_source_0</source_block_id><sink_block_id>xlating_fir_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_1</source_block_id><sink_block_id>audio_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>xlating_fir_filter</source_block_id><sink_block_id>low_pass_filter</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
